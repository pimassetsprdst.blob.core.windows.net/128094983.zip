Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-04-20T15:24:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 20 15:24:18 2018 * Host: B3ROBRAWR3853 * Database: C:\Users\LC\AppData\Local\Temp\{3B558944-066F-4C1C-9FDF-CBA6CAE2BAE0}\ifc * Database version: 5507 * Database creation date: Fri Apr 20 15:24:17 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Apr 20 15:24:18 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 20 15:24:18 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: LF-U2.1, E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN:LF-U2.1:1351152
In: V00
Type - Material: Color RGB 240-240-240, Color RGB 241-241-241
Type - Dimensions - Diameter: 90 mm; Height: 43.4 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 180 deg
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Electrical Engineering - Connection Voltage: 30 V
Type - Identity Data - Article Description: LF/U2.1 Light Sensor, FM; Article Type: LF/U2.1; Category: EL_BUSSYSTEM_SENSOR; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: LF/U2.1 Light Sensor, FM; EMCS Version: 3.0; ETIM Article Class: EC000927; Family Version: 11.14; GTIN: 4016779664165; Manufacturer: ABB; Manufacturer Art. No.: 2CDG110089R0011; Manufacturer URL: https://new.abb.com/products/2CDG110089R0011; MEPcontent Class: SENSOR; Model: LF/U2.1; OmniClass Number: 23.85.50.24; OmniClass Title: Broadcast Transmission and Reception Equipment; Product Line: KNX - Lighting Control - Light Level Sensors; Revit Version: 2016; Type Name: LF-U2.1; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; Family Name: E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN
Pset_BuildingElementProxyCommon - Reference: LF-U2.1; IsExternal: no
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 0.0134446 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000057653 m3
Electrical - Loads - Power: 0 W
Identity Data - Function Code: E6222BS; Mark: 1
Other - Family: E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN: LF-U2.1; Family and Type: E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN: LF-U2.1; Type: E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN: LF-U2.1; Type Id: E_Light Controller_Sensor Inside_MEPcontent_ABB_INT-EN: LF-U2.1
Phasing - Phase Created: 4. Plan over 10 jaar
